# Keil uVision project 老马示波器.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: 老马示波器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: oled.c main.c spi.c timer.c adc.c
